# Keil uVision project Photodiodes_Inspector_Alpha.uvprojx, settings and files
target Photodiodes_Inspector_Alpha (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F407VGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.8
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Photodiodes_Inspector_Alpha +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c Keyboard.c lcd.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_debug.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_tmr.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
